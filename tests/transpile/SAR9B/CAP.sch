** sch_path: tests/transpile/SAR9B/CAP.sch
**.subckt CAP B A
*.iopin B
*.iopin A
R1 B NC0 (value) m=1
R2 A NC1 (value) m=1
**.ends
.end
